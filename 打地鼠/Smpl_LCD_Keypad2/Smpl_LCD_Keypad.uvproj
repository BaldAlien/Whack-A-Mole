# Keil uVision project Smpl_LCD_Keypad.uvproj, settings and files
target Smpl_LCD_Keypad (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_7seg_Keypad
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: .\;..\..\CMSIS;..\..\Driver\Include;..\..\Driver\Include\Driver;..\..\Driver\Include\NUC1xx-LB_002;..\..\Driver\Include\System
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../CMSIS/: core_cm0.c system_NUC1xx.c startup_NUC1xx.s
  group Source files
    ./: Smpl_LCD_Keypad.c
    ../../Driver/Src/NUC1xx-LB_002/: Ascii_Table.C ScanKey.c Seven_Segment.c
    ../: LCD_Driver.c
  group Library files
    ../../Driver/Src/Driver/: DrvGPIO.c
